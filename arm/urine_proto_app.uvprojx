# Keil uVision project urine_proto_app.uvprojx, settings and files
target nrf51822_xxaa (256K) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_NRF6310 DEBUG SPI_MASTER_0_ENABLE SPI_MASTER_1_ENABLE
  c include: ..\..\..\Include;..\..\..\Include\sdk_soc;..\..\..\Include\app_common;..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c ltc2492_driver.c uart_communication.c
    ../../../Source/: keil_arm_uv4.lnt
  group lib
    ../../../Source/nrf_delay/: nrf_delay.c
    ../../../Source/sdk_soc/: nrf_soc.c
    ../: custom_spi_master.c custom_simple_uart.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: ..\..\..\..\Include;..\..\..\..\Include\sdk_soc;..\..\..\..\Include\app_common;..\
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: as above
  output: spi_master_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
